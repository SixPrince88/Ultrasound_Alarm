# IAR project Ultrasound_Alarm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\CMSIS; ..\CMSIS\Include; ..\User; ..\Libraries\inc; ..\User\Common\inc; ..\User\UserLibrary/inc; ..\User\BSP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ultrasound_Alarm.hex
  ILINK.IlinkOutputFile: Ultrasound_Alarm.out
  ILINK.IlinkIcfFile: E:\ARM\Ultrasound_Alarm\IAR\Config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../User/BSP/src/: hw_fd07_3.c hw_key.c hw_oled.c hw_oled_data.c hw_serial.c hw_signal.c hw_timestamp.c
  group CMSIS
    ../CMSIS/startup/IAR/: startup_stm32f10x_md.s
    ../CMSIS/: system_stm32f10x.c
  group Common
    ../User/Common/src/: hw_i2c.c lowpass_filter.c pid.c sw_i2c.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c
  group UserLibraries
    ../User/UserLibrary/src/: user_adc.c user_delay.c user_dma.c user_exti.c user_gpio.c user_i2c.c user_nvic.c user_serial.c user_tim.c
